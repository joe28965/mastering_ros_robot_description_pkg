Commit message: added joint_control and fixed glitchy urdf

File: urdf/pan_tilt.urdf (robot description, URDF)
Before this commit: robot pan_tilt, 3 links, 2 joints
Links:
- link base_link: mass 1 -> 10
